# Keil uVision project Interface_Plate_for_STM32F030xx.uvprojx, settings and files
target Interface_Plate_Firmware (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Interface_Plate_for_STM32F030xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib;.\Lib\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./User/: main.c uart.c interrupt.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
